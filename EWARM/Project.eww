<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32Lib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\STM32ucshell_tx_demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
