# IAR project STM32ucshell_tx_demo.ewp, settings and files
configuration STM32ucshell_tx_demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; TX_MISRA_ENABLE; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\inc; ..\LibFile; ..\ucShell\Cfg; ..\ucShell\Cmd; ..\ucShell\Source; ..\ucShell\ucLib; ..\ucShell\Terminal\Cfg; ..\ucShell\Terminal\Mode\VT100; ..\ucShell\Terminal\OS\ThreadX; ..\ucShell\Terminal\Serial; ..\ucShell\Terminal\Source; ..\UartLib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F1shellTEST.hex
  ILINK.IlinkOutputFile: STM32ucshell_tx_demo.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RTT_Terminal (ARM, debug)
  as the first configuration, except:
configuration Serial_Terminal (ARM, debug)
  as the first configuration, except:
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Core/Src/: stm32f1xx_it_user.c tx_sample.c
  group Application/User/Core
    ../Core/Src/: crc.c dma.c gpio.c main.c rtc.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c usart.c
  group RTT
    ../LibFile/: SEGGER_RTT.a
  group STM32Lib
    ../LibFile/: STM32Lib.a
  group threadx
    ../LibFile/: ThreadX.a
  group uart_dma
    ../LibFile/: STM32uart_DMA.a
    ../UartLib/: User_IRQ_handler.c
  group ucshell/cfg
    ../ucShell/Cfg/: shell_cfg.h
  group ucshell/sh_shell
    ../ucShell/Cmd/: sh_shell.c sh_shell.h
  group ucshell/shell
    ../ucShell/Source/: shell.c shell.h
  group ucshell/Terminal
    ../ucShell/Terminal/Source/: terminal.c terminal.h
    ../ucShell/Terminal/Mode/VT100/: terminal_mode.c
    ../ucShell/Terminal/Serial/: terminal_RTT.c terminal_serial.c
  group ucshell/Terminal/OS
    ../ucShell/Terminal/OS/ThreadX/: terminal_os.c
  group ucshell/uclib
    ../ucShell/ucLib/: cpu_def.h lib_ascii.c lib_ascii.h lib_cfg.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
